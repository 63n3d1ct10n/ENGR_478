# Keil uVision project interrupts.uvproj, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: interrupts
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: startup_TM4C123.s interrupt.c
    ../../../../driverlib/rvmdk/: driverlib.lib
    ../my_switch/: startup_rvmdk.s
